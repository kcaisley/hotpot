# NangateOpenCellLibrary.macro.lef
# Within MACRO INV_X1
PIN A
  DIRECTION INPUT ;
  ANTENNAGATEAREA 0.05225 ;
  # Other antenna attributes omitted
  PORT
    LAYER metal1 ;
    POLYGON 0.06 0.525 0.165 0.525
            0.165 0.7 0.06 0.7 ;
  END
END A
