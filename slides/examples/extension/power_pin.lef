# NangateOpenCellLibrary.macro.lef
# Within MACRO INV_X1
PIN VDD
  DIRECTION INOUT ;
  USE power ;
  SHAPE ABUTMENT ;
  PORT
    LAYER metal1 ;
    POLYGON 0 1.315 0.04 1.315
      0.04 0.975 0.11 0.975
      0.11 1.315 0.38 1.315
      0.38 1.485 0 1.485 ;
  END
END VDD
